# Keil uVision project ElectricSteer.uvprojx, settings and files
target ElectricSteer (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ElectricSteer +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\stm32f10x_FWLib\inc;..\Project;..\CORE;..\UserDrive
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ../CORE/: startup_stm32f10x_md.s
  group Drivers/STM32F1xx_Driver
    ../stm32f10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c
  group Drivers/CMSIS
    ./: system_stm32f10x.c
  group Application/User
    ./: main.c stm32f10x_it.c
  group Code
    ../UserDrive/: 5182.c ADC.c Delay.c Drv8301.c flash.c GPIO.c HALL.c IWDG.c MotorControl.c SPI.c Timer.c UART.c USART.c
  group Add_Code
    ./: globalvariable.h Protect.h System.h Protect.c System.c readme.txt
